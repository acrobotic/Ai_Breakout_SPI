# Repository acrobotic/Ai_Breakout_SPI

## EAGLE design pcb/ai_breakout_spi.brd

Parts:
J1: 2X03
J2: 1X03
J3: 1X03NOFIRST; 1X03-NOFIRST

Connections:
GND: J1.6, J3.3
MISO: J1.1, J2.1
MOSI: J1.4, J3.2
RST: J1.5, J2.3
SCK: J1.3, J2.2
VCC: J1.2, J3.1

Board: 2 copper layers, 12.7 x 10.2 mm, 3 parts (0 on the bottom side), 6 nets.

## Commit log

2014-10-21 ready for manufacturing
2014-11-05 revising silly mistakes on silkscreen
2015-02-26 minor update
